# Keil uVision project condom.uvprojx, settings and files
target mbed-os5-m3-system (6120000::V6.12::.\ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: condom +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=1
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 TARGET_STM32F103VE COMPONENT_NSPE=1 DEVICE_STDIO_MESSAGES=1 __ASSERT_MSG TARGET_STM32F1 DEVICE_PORTINOUT=1 __CORTEX_M3 DEVICE_SPISLAVE=1 DEVICE_I2C_ASYNCH=1  DEVICE_PWMOUT=0 MBED_TRAP_ERRORS_ENABLED=1 DEVICE_CAN=0 DEVICE_PORTOUT=1 DEVICE_FLASH=0 MBED_BUILD_TIMESTAMP=1555425826.49 TARGET_RELEASE TARGET_LIKE_MBED ARM_MATH_CM3 DEVICE_INTERRUPTIN=1 TARGET_LIKE_CORTEX_M3 DEVICE_ANALOGIN=1 TARGET_NUCLEO_F103VE DEVICE_PORTIN=1 TARGET_CORTEX_M DEVICE_SERIAL_FC=1 MULADDC_CANNOT_USE_R7 MBED_RAM_START=0x20000000 DEVICE_USTICKER=1 DEVICE_I2C=1 COMPONENT_PSA_SRV_IMPL=1 COMPONENT_PSA_SRV_EMUL=1 TOOLCHAIN_ARM TOOLCHAIN_ARM_STD TARGET_STM DEVICE_SERIAL_ASYNCH=1 MBED_RAM_SIZE=0x10000 TARGET_FAMILY_STM32 DEVICE_SPI=1 TARGET_NAME=NUCLEO_F103VE __MBED__=1 __MBED_CMSIS_RTOS_CM MBED_ROM_SIZE=0x80000 TARGET_FF_MORPHO DEVICE_SERIAL=1 TARGET_M3 MBED_ROM_START=0x8000000 TARGET_CORTEX DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 TOOLCHAIN_ARMC6
  c misc: -fshort-wchar -Wno-armcc-pragma-anon-unions -fno-exceptions -fno-rtti -fshort-enums -mthumb --target=arm-arm-none-eabi -Wno-armcc-pragma-push-pop -c -fdata-sections -mcpu=cortex-m3 -include mbed_config.h
  c include: ;../mbed-os-m3;../mbed-os-m3/cmsis;../mbed-os-m3/cmsis/TARGET_CORTEX_M;../mbed-os-m3/components;../mbed-os-m3/components/802.15.4_RF;../mbed-os-m3/components/802.15.4_RF/atmel-rf-driver;../mbed-os-m3/components/802.15.4_RF/atmel-rf-driver/atmel-rf-driver;../mbed-os-m3/components/802.15.4_RF/atmel-rf-driver/source;../mbed-os-m3/components/802.15.4_RF/mcr20a-rf-driver;../mbed-os-m3/components/802.15.4_RF/mcr20a-rf-driver/mcr20a-rf-driver;../mbed-os-m3/components/802.15.4_RF/mcr20a-rf-driver/source;../mbed-os-m3/components/802.15.4_RF/stm-s2lp-rf-driver;../mbed-os-m3/components/802.15.4_RF/stm-s2lp-rf-driver/source;../mbed-os-m3/components/802.15.4_RF/stm-s2lp-rf-driver/stm-s2lp-rf-driver;../mbed-os-m3/components/wifi;../mbed-os-m3/components/wifi/esp8266-driver;../mbed-os-m3/components/wifi/esp8266-driver/ESP8266;../mbed-os-m3/drivers;../mbed-os-m3/events;../mbed-os-m3/events/equeue;../mbed-os-m3/features;../mbed-os-m3/features/cellular;../mbed-os-m3/features/cellular/framework;../mbed-os-m3/features/cellular/framework/API;../mbed-os-m3/features/cellular/framework/AT;../mbed-os-m3/features/cellular/framework/common;../mbed-os-m3/features/cellular/framework/device;../mbed-os-m3/features/cellular/framework/targets;../mbed-os-m3/features/cellular/framework/targets/GEMALTO;../mbed-os-m3/features/cellular/framework/targets/GEMALTO/CINTERION;../mbed-os-m3/features/cellular/framework/targets/GENERIC;../mbed-os-m3/features/cellular/framework/targets/GENERIC/GENERIC_AT3GPP;../mbed-os-m3/features/cellular/framework/targets/MultiTech;../mbed-os-m3/features/cellular/framework/targets/MultiTech/DragonflyNano;../mbed-os-m3/features/cellular/framework/targets/MultiTech/DragonflyNano/PPP;../mbed-os-m3/features/cellular/framework/targets/QUECTEL;../mbed-os-m3/features/cellular/framework/targets/QUECTEL/BC95;../mbed-os-m3/features/cellular/framework/targets/QUECTEL/BG96;../mbed-os-m3/features/cellular/framework/targets/QUECTEL/M26;../mbed-os-m3/features/cellular/framework/targets/QUECTEL/UG96;../mbed-os-m3/features/cellular/framework/targets/TELIT;../mbed-os-m3/features/cellular/framework/targets/TELIT/HE910;../mbed-os-m3/features/cellular/framework/targets/UBLOX;../mbed-os-m3/features/cellular/framework/targets/UBLOX/AT;../mbed-os-m3/features/cellular/framework/targets/UBLOX/PPP;../mbed-os-m3/features/device_key;../mbed-os-m3/features/device_key/source;../mbed-os-m3/features/frameworks;../mbed-os-m3/features/frameworks/greentea-client;../mbed-os-m3/features/frameworks/greentea-client/greentea-client;../mbed-os-m3/features/frameworks/mbed-client-cli;../mbed-os-m3/features/frameworks/mbed-client-cli/mbed-client-cli;../mbed-os-m3/features/frameworks/mbed-client-randlib;../mbed-os-m3/features/frameworks/mbed-client-randlib/mbed-client-randlib;../mbed-os-m3/features/frameworks/mbed-client-randlib/mbed-client-randlib/platform;../mbed-os-m3/features/frameworks/mbed-coap;../mbed-os-m3/features/frameworks/mbed-coap/mbed-coap;../mbed-os-m3/features/frameworks/mbed-coap/source;../mbed-os-m3/features/frameworks/mbed-coap/source/include;../mbed-os-m3/features/frameworks/mbed-trace;../mbed-os-m3/features/frameworks/mbed-trace/mbed-trace;../mbed-os-m3/features/frameworks/nanostack-libservice;../mbed-os-m3/features/frameworks/nanostack-libservice/mbed-client-libservice;../mbed-os-m3/features/frameworks/nanostack-libservice/mbed-client-libservice/platform;../mbed-os-m3/features/frameworks/unity;../mbed-os-m3/features/frameworks/unity/unity;../mbed-os-m3/features/frameworks/utest;../mbed-os-m3/features/frameworks/utest/utest;../mbed-os-m3/features/lorawan;../mbed-os-m3/features/lorawan/lorastack;../mbed-os-m3/features/lorawan/lorastack/mac;../mbed-os-m3/features/lorawan/lorastack/phy;../mbed-os-m3/features/lorawan/system;../mbed-os-m3/features/lwipstack;../mbed-os-m3/features/lwipstack/lwip;../mbed-os-m3/features/lwipstack/lwip-sys;../mbed-os-m3/features/lwipstack/lwip-sys/arch;../mbed-os-m3/features/lwipstack/lwip/src;../mbed-os-m3/features/lwipstack/lwip/src/include;../mbed-os-m3/features/lwipstack/lwip/src/include/lwip;../mbed-os-m3/features/lwipstack/lwip/src/include/lwip/priv;../mbed-os-m3/features/lwipstack/lwip/src/include/lwip/prot;../mbed-os-m3/features/lwipstack/lwip/src/include/netif;../mbed-os-m3/features/lwipstack/lwip/src/include/netif/ppp;../mbed-os-m3/features/lwipstack/lwip/src/include/netif/ppp/polarssl;../mbed-os-m3/features/mbedtls;../mbed-os-m3/features/mbedtls/inc;../mbed-os-m3/features/mbedtls/inc/mbedtls;../mbed-os-m3/features/mbedtls/mbed-crypto;../mbed-os-m3/features/mbedtls/mbed-crypto/inc;../mbed-os-m3/features/mbedtls/mbed-crypto/inc/psa;../mbed-os-m3/features/mbedtls/platform;../mbed-os-m3/features/mbedtls/platform/inc;../mbed-os-m3/features/mbedtls/targets/TARGET_STM;../mbed-os-m3/features/nanostack;../mbed-os-m3/features/nanostack/coap-service;../mbed-os-m3/features/nanostack/coap-service/coap-service;../mbed-os-m3/features/nanostack/coap-service/source;../mbed-os-m3/features/nanostack/coap-service/source/include;../mbed-os-m3/features/nanostack/mbed-mesh-api;../mbed-os-m3/features/nanostack/mbed-mesh-api/mbed-mesh-api;../mbed-os-m3/features/nanostack/mbed-mesh-api/source;../mbed-os-m3/features/nanostack/mbed-mesh-api/source/include;../mbed-os-m3/features/nanostack/nanostack-hal-mbed-cmsis-rtos;../mbed-os-m3/features/nanostack/nanostack-interface;../mbed-os-m3/features/nanostack/sal-stack-nanostack;../mbed-os-m3/features/nanostack/sal-stack-nanostack-eventloop;../mbed-os-m3/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop;../mbed-os-m3/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/platform;../mbed-os-m3/features/nanostack/sal-stack-nanostack-eventloop/source;../mbed-os-m3/features/nanostack/sal-stack-nanostack/nanostack;../mbed-os-m3/features/nanostack/sal-stack-nanostack/nanostack/platform;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Fragmentation;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/IPHC_Decode;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/MAC;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Mesh;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/ND;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/NVM;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Thread;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/6LoWPAN/ws;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/BorderRouter;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Common_Protocols;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Core;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Core/include;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/DHCPv6_Server;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/DHCPv6_client;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/MAC;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/MAC/IEEE802_15_4;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/MAC/virtual_rf;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/MLE;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/MPL;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/Include;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/RPL;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/Common;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/PANA;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/TLS;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/eapol;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/kmp;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/protocols;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/protocols/eap_tls_sec_prot;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/protocols/fwh_sec_prot;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/protocols/gkh_sec_prot;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/protocols/key_sec_prot;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Security/protocols/tls_sec_prot;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/Neighbor_cache;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/Trickle;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/blacklist;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/etx;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/fhss;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/fnv_hash;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/hmac;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/ieee_802_11;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/load_balance;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mac_neighbor_table;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/compiler;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/cpu;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/dns;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/mdns;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/poll;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/serial;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/stack;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/mle_service;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/nd_proxy;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/nist_aes_kw;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/pan_blacklist;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/utils;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/Service_Libs/whiteboard;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/configs;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/configs/base;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/ipv6_stack;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/libDHCPv6;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/libNET;../mbed-os-m3/features/nanostack/sal-stack-nanostack/source/libNET/src;../mbed-os-m3/features/netsocket;../mbed-os-m3/features/netsocket/cellular;../mbed-os-m3/features/nfc;../mbed-os-m3/features/nfc/acore;../mbed-os-m3/features/nfc/acore/acore;../mbed-os-m3/features/nfc/controllers;../mbed-os-m3/features/nfc/nfc;../mbed-os-m3/features/nfc/nfc/ndef;../mbed-os-m3/features/nfc/nfc/ndef/common;../mbed-os-m3/features/nfc/stack;../mbed-os-m3/features/nfc/stack/ndef;../mbed-os-m3/features/nfc/stack/platform;../mbed-os-m3/features/nfc/stack/tech;../mbed-os-m3/features/nfc/stack/tech/iso7816;../mbed-os-m3/features/nfc/stack/tech/isodep;../mbed-os-m3/features/nfc/stack/tech/type4;../mbed-os-m3/features/nfc/stack/transceiver;../mbed-os-m3/features/nfc/stack/transceiver/pn512;../mbed-os-m3/features/storage;../mbed-os-m3/features/storage/blockdevice;../mbed-os-m3/features/storage/filesystem;../mbed-os-m3/features/storage/filesystem/fat;../mbed-os-m3/features/storage/filesystem/fat/ChaN;../mbed-os-m3/features/storage/filesystem/littlefs;../mbed-os-m3/features/storage/filesystem/littlefs/littlefs;../mbed-os-m3/features/storage/kvstore;../mbed-os-m3/features/storage/kvstore/conf;../mbed-os-m3/features/storage/kvstore/direct_access_devicekey;../mbed-os-m3/features/storage/kvstore/filesystemstore;../mbed-os-m3/features/storage/kvstore/global_api;../mbed-os-m3/features/storage/kvstore/include;../mbed-os-m3/features/storage/kvstore/kv_map;../mbed-os-m3/features/storage/kvstore/securestore;../mbed-os-m3/features/storage/kvstore/tdbstore;../mbed-os-m3/features/storage/nvstore;../mbed-os-m3/features/storage/nvstore/source;../mbed-os-m3/features/storage/system_storage;../mbed-os-m3/hal;../mbed-os-m3/hal/storage_abstraction;../mbed-os-m3/platform;../mbed-os-m3/rtos;../mbed-os-m3/rtos/TARGET_CORTEX;../mbed-os-m3/rtos/TARGET_CORTEX/rtx4;../mbed-os-m3/rtos/TARGET_CORTEX/rtx5;../mbed-os-m3/rtos/TARGET_CORTEX/rtx5/Include;../mbed-os-m3/rtos/TARGET_CORTEX/rtx5/RTX;../mbed-os-m3/rtos/TARGET_CORTEX/rtx5/RTX/Config;../mbed-os-m3/rtos/TARGET_CORTEX/rtx5/RTX/Include;../mbed-os-m3/rtos/TARGET_CORTEX/rtx5/RTX/Source;../mbed-os-m3/targets/TARGET_STM;../mbed-os-m3/targets/TARGET_STM/TARGET_STM32F1;../mbed-os-m3/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103VE;../mbed-os-m3/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103VE/device;../mbed-os-m3/targets/TARGET_STM/TARGET_STM32F1/device;../mbed-os-m3/usb;../mbed-os-m3/usb/device;../mbed-os-m3/usb/device/USBAudio;../mbed-os-m3/usb/device/USBDevice;../mbed-os-m3/usb/device/USBHID;../mbed-os-m3/usb/device/USBMIDI;../mbed-os-m3/usb/device/USBMSD;../mbed-os-m3/usb/device/USBPhy;../mbed-os-m3/usb/device/USBSerial;../mbed-os-m3/usb/device/hal;../mbed-os-m3/usb/device/targets/TARGET_STM;../mbed-os-m3/usb/device/utilities;../mbed-os-m3/usb/device/utilities/events
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f103xe.sct
  link misc: --show_full_path --predefine="-DMBED_BOOT_STACK_SIZE=1024" --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_RAM_SIZE=0x10000" --predefine="-DMBED_ROM_SIZE=0x20000" --cpu=cortex-m3 --keep=os_cb_sections
  group source
    ./: main.cpp mbed_config.h stats_report.h
  group libs
    ./libs/: mbed-os-m3.lib
  group startup
    ../mbed-os-m3/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103VE/device/TOOLCHAIN_ARM_STD/: startup_stm32f103xe.S
