# Keil uVision project mbed.uvprojx, settings and files
target mbed-src (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M3")
  output: mbed-src (library)
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 TARGET_STM32F103RB COMPONENT_NSPE=1 MBED_BUILD_TIMESTAMP=1555085300.01 __ASSERT_MSG TARGET_STM32F1 DEVICE_PORTINOUT=1 __CORTEX_M3 DEVICE_SPISLAVE=1 DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO DEVICE_PWMOUT=1 DEVICE_CAN=0 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 TARGET_RELEASE TARGET_LIKE_MBED ARM_MATH_CM3 TARGET_LIKE_CORTEX_M3 DEVICE_ANALOGIN=1 TARGET_NUCLEO_F103RB TARGET_CORTEX_M MBED_ROM_START=0x8000000 DEVICE_USTICKER=1 DEVICE_I2C=1 MBED_RAM_START=0x20000000 DEVICE_PORTIN=1 COMPONENT_PSA_SRV_IMPL=1 COMPONENT_PSA_SRV_EMUL=1 TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TOOLCHAIN_ARM_STD TARGET_STM DEVICE_SERIAL_ASYNCH=1 MBED_RAM_SIZE=0x5000 TARGET_FAMILY_STM32 DEVICE_SPI=1 TARGET_NAME=NUCLEO_F103RB __MBED__=1 DEVICE_SERIAL_FC=1 MBED_ROM_SIZE=0x20000 TARGET_FF_MORPHO DEVICE_SERIAL=1 TARGET_M3 TARGET_CORTEX DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM
  c misc: --split_sections --no_rtti --cpu=Cortex-M3 --apcs=interwork --no_depend_system_headers --md --gnu -c --preinclude=mbed_config.h
  c include: api;hal;targets;targets/cmsis;targets/cmsis/TARGET_STM/TARGET_NUCLEO_F103RB;targets/hal/TARGET_STM/TARGET_NUCLEO_F103RB
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\targets\cmsis\TARGET_STM\TARGET_NUCLEO_F103RB\TOOLCHAIN_ARM_STD\stm32f10x.sct
  link misc: --predefine="-DMBED_ROM_SIZE=0x20000" --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_START=0x20000000" --show_full_path --predefine="-DMBED_BOOT_STACK_SIZE=4096" --keep=os_cb_sections --predefine="-DMBED_RAM_SIZE=0x5000"
  group api
    api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h platform.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h wait_api.h
  group common
    common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp exit.c FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group hal
    hal/: analogin_api.h analogout_api.h can_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h us_ticker_api.h
  group mbed-src
    ./: mbed_config.h
  group targets
    targets/hal/TARGET_STM/TARGET_NUCLEO_F103RB/: analogin_api.c device.h gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c mbed_overrides.c objects.h PeripheralNames.h PeripheralPins.c PeripheralPins.h pinmap.c PinNames.h port_api.c PortNames.h pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    targets/cmsis/TARGET_STM/TARGET_NUCLEO_F103RB/: cmsis.h cmsis_nvic.c cmsis_nvic.h misc.c misc.h stm32f10x.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h system_stm32f10x.c system_stm32f10x.h
    targets/cmsis/: core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    targets/cmsis/TARGET_STM/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD/: startup_stm32f10x_md.s sys.cpp
