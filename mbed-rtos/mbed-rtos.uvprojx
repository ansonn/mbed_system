# Keil uVision project mbed-rtos.uvprojx, settings and files
target rtos (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M3")
  output: rtos (library)
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 TARGET_STM32F103RB COMPONENT_NSPE=1 __ASSERT_MSG TARGET_STM32F1 DEVICE_PORTINOUT=1 __CORTEX_M3 DEVICE_SPISLAVE=1 DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO DEVICE_PWMOUT=1 DEVICE_CAN=0 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 TARGET_RELEASE TARGET_LIKE_MBED ARM_MATH_CM3 TARGET_LIKE_CORTEX_M3 MBED_BUILD_TIMESTAMP=1555087209.06 TARGET_NUCLEO_F103RB TARGET_CORTEX_M MBED_ROM_START=0x8000000 DEVICE_USTICKER=1 DEVICE_I2C=1 MBED_RAM_START=0x20000000 DEVICE_PORTIN=1 COMPONENT_PSA_SRV_IMPL=1 COMPONENT_PSA_SRV_EMUL=1 TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 DEVICE_ANALOGIN=1 TOOLCHAIN_ARM_STD TARGET_STM DEVICE_SERIAL_ASYNCH=1 MBED_RAM_SIZE=0x5000 TARGET_FAMILY_STM32 DEVICE_SPI=1 TARGET_NAME=NUCLEO_F103RB __MBED__=1 DEVICE_SERIAL_FC=1 MBED_ROM_SIZE=0x20000 TARGET_FF_MORPHO DEVICE_SERIAL=1 TARGET_M3 TARGET_CORTEX DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM
  c misc: --split_sections --no_rtti --cpu=Cortex-M3 --apcs=interwork --no_depend_system_headers --md --gnu -c --preinclude=mbed_config.h
  c include: mbed-rtos;mbed-rtos/rtos;mbed-rtos/rtx;mbed;mbed/TARGET_NUCLEO_F103RB;mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_NUCLEO_F103RB
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: /filer/web_data/repo_builds/4/238/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD/stm32f10x.sct
  link misc: --predefine="-DMBED_ROM_SIZE=0x20000" --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_START=0x20000000" --show_full_path --predefine="-DMBED_BOOT_STACK_SIZE=4096" --keep=os_cb_sections --predefine="-DMBED_RAM_SIZE=0x5000"
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar mbed_overrides.o misc.o retarget.o startup_stm32f10x_md.o stm32f10x_adc.o stm32f10x_bkp.o stm32f10x_can.o stm32f10x_cec.o stm32f10x_crc.o stm32f10x_dac.o stm32f10x_dbgmcu.o stm32f10x_dma.o stm32f10x_exti.o stm32f10x_flash.o stm32f10x_fsmc.o stm32f10x_gpio.o stm32f10x_i2c.o stm32f10x_iwdg.o stm32f10x_pwr.o stm32f10x_rcc.o stm32f10x_rtc.o stm32f10x_sdio.o stm32f10x_spi.o stm32f10x_tim.o stm32f10x_usart.o stm32f10x_wwdg.o sys.o system_stm32f10x.o
    mbed/TARGET_NUCLEO_F103RB/: cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h system_stm32f10x.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_NUCLEO_F103RB/: device.h gpio_object.h objects.h PeripheralNames.h PinNames.h PortNames.h
  group mbed-rtos
    mbed-rtos/rtx/: cmsis_os.h HAL_CM.c os_tcb.h rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Mutex.c rt_Mutex.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf.h RTX_Conf_CM.c
    mbed-rtos/rtx/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.s
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group rtos-test
    ./: mbed_config.h
